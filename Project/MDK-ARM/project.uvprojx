# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=..\output(mdk).bin Flash\Obj\output.axf
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\commPlatform;..\..\User\app\inc;..\..\User\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../User/app/src/: main.c task.c afeStateMachine.c globle.c protocol_task.c
    ../../User/app/inc/: task.h afeStateMachine.h globle.h protocol_task.h
  group 软件层
    ../../User/mid/: mmath.c mmath.h
  group BSP
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.h stm32f10x_it.c stm32f10x_conf.h stm32f10x_assert.c system_stm32f10x.h system_stm32f10x.c
    ../../User/bsp/inc/: bsp_timer.h bsp_key.h bsp_uart_fifo.h bsp_afe4300_spi.h bsp_led.h bsp_i2c.h bsp_mux508.h bsp_shtc3.h bsp_flash.h bsp_spi.h bsp_data_interface.h bsp_oled_font.h bsp_oled.h bsp_gpio.h bsp_w25q128.h bsp_dac.h
    ../../User/bsp/src/: bsp_timer.c bsp_key.c bsp_uart_fifo.c bsp_afe4300_spi.c bsp_led.c bsp_i2c.c bsp_mux508.c bsp_shtc3.c bsp_flash.c bsp_spi.c bsp_data_interface.c bsp_oled.c bsp_gpio.c bsp_w25q128.c bsp_dac.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_gpio.h stm32f10x_rcc.h misc.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_wwdg.h
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Include/: stm32f10x.h
    ../../Libraries/CMSIS/Include/: core_cm3.h core_cmFunc.h core_cmInstr.h arm_common_tables.h arm_math.h
  group Doc
    ../../User/commPlatform/: instructions.h
    ../../Doc/: 02.开发环境说明.txt
    ./: 修改说明.txt
  group CommPlatform
    ../../User/commPlatform/: AppLayer.c AppLayer.h DataLinkLayer.c DataLinkLayer.h HardwareLayer.c HardwareLayer.h protocol.c protocol.h platformdef.h
  group config
    ../../User/: global_config.h hardware_config.h
  group doc
    ../../User/: 修改历史记录.txt
target CpuRAM (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target ZK1_0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: output +hex
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=..\ZK1_0.bin ZK1_0\Obj\output.axf
  AfterMake: CopyHex_ZK1_0.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_USART_PRINT_DEBUG_
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
